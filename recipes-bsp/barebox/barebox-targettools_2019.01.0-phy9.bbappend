COMPATIBLE_MACHINE += "|nio-controller"

